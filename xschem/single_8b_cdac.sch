v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {x8b_cap_array.sym} 570 -460 0 0 {name=x2}
C {devices/lab_wire.sym} 420 -470 0 0 {name=p9 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 720 -470 0 1 {name=p16 sig_type=std_logic lab=VC}
C {devices/ipin.sym} 180 -580 0 0 {name=p18 lab=VDD}
C {devices/ipin.sym} 180 -560 0 0 {name=p19 lab=CF[0:7]}
C {devices/ipin.sym} 180 -540 0 0 {name=p20 lab=SW_IN[0:7]}
C {devices/ipin.sym} 180 -520 0 0 {name=p22 lab=VCM}
C {devices/ipin.sym} 180 -500 0 0 {name=p23 lab=VSS}
C {devices/iopin.sym} 160 -470 0 0 {name=p24 lab=VC}
C {cdac_sw_1.sym} 570 -550 0 0 {name=x10[0:7]}
C {devices/lab_wire.sym} 420 -590 0 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 420 -510 0 0 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 720 -590 2 0 {name=p67 sig_type=std_logic lab=SWN[0:7]}
C {devices/lab_wire.sym} 420 -530 0 0 {name=p70 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 420 -570 0 0 {name=p71 sig_type=std_logic lab=CF[0:7]}
C {devices/lab_wire.sym} 420 -550 0 0 {name=p73 sig_type=std_logic lab=SW_IN[0:7]}
C {devices/lab_wire.sym} 420 -450 0 0 {name=p1 sig_type=std_logic lab=SWN[0:7]}
