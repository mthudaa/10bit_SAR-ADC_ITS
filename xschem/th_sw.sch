v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 60 -190 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 60 -170 0 0 {name=p12 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 60 -150 0 0 {name=p13 sig_type=std_logic lab=CK}
C {devices/ipin.sym} 60 -130 0 0 {name=p14 sig_type=std_logic lab=CKB}
C {devices/ipin.sym} 60 -110 0 0 {name=p15 sig_type=std_logic lab=IN}
C {devices/opin.sym} 60 -70 0 0 {name=p16 sig_type=std_logic lab=OUT}
C {th_sw_main.sym} 370 -70 0 0 {name=x1}
C {bootstrap.sym} 370 -190 0 0 {name=x2}
C {devices/lab_wire.sym} 220 -110 0 0 {name=p1 lab=VDD}
C {devices/lab_wire.sym} 220 -90 0 0 {name=p2 lab=VSS}
C {devices/lab_wire.sym} 220 -70 0 0 {name=p3 lab=CK}
C {devices/lab_wire.sym} 220 -50 0 0 {name=p4 lab=VGS}
C {devices/lab_wire.sym} 220 -30 0 0 {name=p5 lab=IN}
C {devices/lab_wire.sym} 520 -110 0 1 {name=p6 lab=OUT}
C {devices/lab_wire.sym} 220 -230 0 0 {name=p7 lab=VDD}
C {devices/lab_wire.sym} 220 -210 0 0 {name=p8 lab=VSS}
C {devices/lab_wire.sym} 220 -190 0 0 {name=p9 lab=CK}
C {devices/lab_wire.sym} 220 -170 0 0 {name=p10 lab=CKB}
C {devices/lab_wire.sym} 220 -150 0 0 {name=p17 lab=IN}
C {devices/lab_wire.sym} 520 -230 0 1 {name=p18 lab=VGS}
