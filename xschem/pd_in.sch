v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 100 -260 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 100 -220 0 0 {name=p8 sig_type=std_logic lab=INP}
C {devices/ipin.sym} 100 -200 0 0 {name=p9 sig_type=std_logic lab=INN}
C {devices/ipin.sym} 100 -240 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 80 -140 0 0 {name=p13 sig_type=std_logic lab=A}
C {devices/opin.sym} 80 -120 0 0 {name=p14 sig_type=std_logic lab=B}
C {pd_in_half.sym} 370 -230 0 0 {name=x1}
C {pd_in_half.sym} 370 -90 0 0 {name=x2}
C {devices/lab_wire.sym} 220 -270 0 0 {name=p1 lab=VDD}
C {devices/lab_wire.sym} 220 -250 0 0 {name=p2 lab=VSS}
C {devices/lab_wire.sym} 220 -230 0 0 {name=p3 lab=INP}
C {devices/lab_wire.sym} 220 -210 0 0 {name=p4 lab=INN}
C {devices/lab_wire.sym} 520 -130 0 1 {name=p5 lab=B}
C {devices/lab_wire.sym} 520 -270 0 1 {name=p6 lab=A}
C {devices/lab_wire.sym} 220 -130 0 0 {name=p11 lab=VDD}
C {devices/lab_wire.sym} 220 -110 0 0 {name=p12 lab=VSS}
C {devices/lab_wire.sym} 220 -70 0 0 {name=p15 lab=INP}
C {devices/lab_wire.sym} 220 -90 0 0 {name=p16 lab=INN}
C {devices/lab_wire.sym} 220 -190 0 0 {name=p17 lab=B}
C {devices/lab_wire.sym} 220 -50 0 0 {name=p18 lab=A}
