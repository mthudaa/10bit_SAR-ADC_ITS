v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {cdac.sym} 520 -600 0 0 {name=x2}
C {th_dif_sw.sym} 520 -320 0 0 {name=x3}
C {devices/lab_wire.sym} 670 -160 0 1 {name=p20 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 670 -140 0 1 {name=p22 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 670 -120 0 1 {name=p23 sig_type=std_logic lab=DOUT[0:9]}
C {devices/lab_wire.sym} 670 -100 0 1 {name=p24 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 670 -200 0 1 {name=p12 sig_type=std_logic lab=CKSB}
C {devices/lab_wire.sym} 670 -220 0 1 {name=p13 sig_type=std_logic lab=CKS}
C {devices/lab_wire.sym} 370 -310 0 0 {name=p1 sig_type=std_logic lab=CKSB}
C {devices/lab_wire.sym} 370 -330 0 0 {name=p2 sig_type=std_logic lab=CKS}
C {devices/lab_wire.sym} 370 -220 0 0 {name=p7 sig_type=std_logic lab=VDDD}
C {devices/lab_wire.sym} 370 -200 0 0 {name=p3 sig_type=std_logic lab=VSSD}
C {devices/lab_wire.sym} 370 -160 0 0 {name=p9 sig_type=std_logic lab=RDY}
C {devices/lab_wire.sym} 370 -140 0 0 {name=p28 sig_type=std_logic lab=CMP_P}
C {devices/lab_wire.sym} 370 -120 0 0 {name=p29 sig_type=std_logic lab=CMP_N}
C {devices/lab_wire.sym} 670 -500 0 1 {name=p4 sig_type=std_logic lab=CMP_P}
C {devices/lab_wire.sym} 670 -480 0 1 {name=p5 sig_type=std_logic lab=CMP_N}
C {devices/lab_wire.sym} 370 -290 0 0 {name=p6 sig_type=std_logic lab=VINP}
C {devices/lab_wire.sym} 370 -270 0 0 {name=p8 sig_type=std_logic lab=VINN}
C {devices/lab_wire.sym} 670 -370 0 1 {name=p10 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 670 -350 0 1 {name=p11 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 370 -440 0 0 {name=p14 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 370 -420 0 0 {name=p15 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 670 -650 0 1 {name=p16 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 670 -630 0 1 {name=p17 sig_type=std_logic lab=VCN}
C {devices/lab_wire.sym} 370 -570 0 0 {name=p18 sig_type=std_logic lab=SWP[0:9]}
C {devices/lab_wire.sym} 370 -550 0 0 {name=p19 sig_type=std_logic lab=SWN[0:9]}
C {devices/lab_wire.sym} 370 -590 0 0 {name=p21 sig_type=std_logic lab=CF[0:9]}
C {devices/lab_wire.sym} 370 -370 0 0 {name=p25 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 370 -350 0 0 {name=p26 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 370 -480 0 0 {name=p27 sig_type=std_logic lab=VDDA}
C {devices/lab_wire.sym} 370 -460 0 0 {name=p30 sig_type=std_logic lab=VSSA}
C {devices/lab_wire.sym} 370 -500 0 0 {name=p31 sig_type=std_logic lab=CLK}
C {devices/lab_wire.sym} 370 -650 0 0 {name=p32 sig_type=std_logic lab=VDDR}
C {devices/lab_wire.sym} 370 -630 0 0 {name=p33 sig_type=std_logic lab=VSSR}
C {devices/lab_wire.sym} 370 -610 0 0 {name=p36 sig_type=std_logic lab=VCM}
C {devices/ipin.sym} 120 -660 0 0 {name=p38 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 120 -640 0 0 {name=p39 sig_type=std_logic lab=VSSA}
C {devices/ipin.sym} 120 -520 0 0 {name=p40 sig_type=std_logic lab=CLK}
C {devices/ipin.sym} 120 -500 0 0 {name=p41 sig_type=std_logic lab=VINP}
C {devices/ipin.sym} 120 -480 0 0 {name=p42 sig_type=std_logic lab=VINN}
C {devices/opin.sym} 100 -440 0 0 {name=p43 sig_type=std_logic lab=DOUT[0:9]}
C {devices/opin.sym} 100 -420 0 0 {name=p44 sig_type=std_logic lab=CKO}
C {devices/lab_wire.sym} 670 -180 0 1 {name=p45 sig_type=std_logic lab=CF[0:9]}
C {devices/ipin.sym} 120 -540 0 0 {name=p37 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 370 -100 0 0 {name=p34 sig_type=std_logic lab=EN}
C {devices/ipin.sym} 120 -460 0 0 {name=p35 sig_type=std_logic lab=EN}
C {devices/lab_wire.sym} 670 -460 0 1 {name=p46 sig_type=std_logic lab=RDY}
C {devices/lab_wire.sym} 370 -180 0 0 {name=p47 sig_type=std_logic lab=CLK}
C {tdc.sym} 520 -460 0 0 {name=x1}
C {sar10b.sym} 520 -160 0 0 {name=x4}
C {devices/ipin.sym} 120 -620 0 0 {name=p48 sig_type=std_logic lab=VDDD}
C {devices/ipin.sym} 120 -600 0 0 {name=p49 sig_type=std_logic lab=VSSD}
C {devices/ipin.sym} 120 -580 0 0 {name=p50 sig_type=std_logic lab=VDDR}
C {devices/ipin.sym} 120 -560 0 0 {name=p51 sig_type=std_logic lab=VSSR}
C {devices/code_shown.sym} 70 -40 0 0 {name=s1 only_toplevel=false value=".include /usr/local/share/pdk/sky130A/libs.ref/sky130_fd_sc_hs/spice/sky130_fd_sc_hs.spice"}
