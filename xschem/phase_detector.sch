v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 120 -240 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 120 -200 0 0 {name=p8 sig_type=std_logic lab=INP}
C {devices/ipin.sym} 120 -180 0 0 {name=p9 sig_type=std_logic lab=INN}
C {devices/ipin.sym} 120 -220 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 100 -120 0 0 {name=p13 sig_type=std_logic lab=OUTP}
C {devices/opin.sym} 100 -100 0 0 {name=p14 sig_type=std_logic lab=OUTN}
C {devices/opin.sym} 100 -80 0 0 {name=p26 sig_type=std_logic lab=RDY}
C {pd_in.sym} 450 -200 0 0 {name=x1}
C {pd_out.sym} 450 -80 0 0 {name=x2}
C {devices/lab_wire.sym} 300 -230 0 0 {name=p1 lab=VDD}
C {devices/lab_wire.sym} 300 -210 0 0 {name=p2 lab=VSS}
C {devices/lab_wire.sym} 300 -190 0 0 {name=p3 lab=INP}
C {devices/lab_wire.sym} 300 -170 0 0 {name=p4 lab=INN}
C {devices/lab_wire.sym} 600 -230 0 1 {name=p5 lab=A}
C {devices/lab_wire.sym} 600 -210 0 1 {name=p6 lab=B}
C {devices/lab_wire.sym} 300 -110 0 0 {name=p11 lab=VDD}
C {devices/lab_wire.sym} 300 -90 0 0 {name=p12 lab=VSS}
C {devices/lab_wire.sym} 300 -70 0 0 {name=p15 lab=A}
C {devices/lab_wire.sym} 300 -50 0 0 {name=p16 lab=B}
C {devices/lab_wire.sym} 600 -110 0 1 {name=p17 lab=OUTP}
C {devices/lab_wire.sym} 600 -90 0 1 {name=p18 lab=OUTN}
C {devices/lab_wire.sym} 600 -70 0 1 {name=p19 lab=RDY}
